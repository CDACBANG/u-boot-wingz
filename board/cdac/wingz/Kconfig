## board/cdac/wingz/Kconfig
```kconfig
if TARGET_OMAP3_WINGZ

config SYS_BOARD
	default "wingz"

config SYS_VENDOR
	default "cdac"

config SYS_CONFIG_NAME
	default "omap3_wingz"

endif
```
